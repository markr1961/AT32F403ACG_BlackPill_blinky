# IAR project AT32F403ACGU7_Blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403ACGU7_v2 ArteryTek -AT32F403ACGU7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F403ACGU7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1; DEBUG
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AT32F403ACGU7_Blinky.hex
  ILINK.IlinkOutputFile: AT32F403ACGU7_Blinky.out
  ILINK.IlinkIcfFile: AT32F403AxG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403ACGU7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_debug.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c
  group user
    ../src/: at32f403a_407_int.c at32f403a_407_wk_config.c main.c
